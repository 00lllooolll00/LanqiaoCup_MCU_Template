# Keil uVision project NewTemplateByNintyNine99.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: NewTemplateByNintyNine99 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\Inc;..\Driver\Inc
  group Driver
    ../Driver/Src/: Delay.c Key.c LED.c Seg.c SysInit.c TIM.c Periph.c iic.c onewire.c ds1302.c Ultrasonic.c Serial.c
  group User
    ./: STARTUP.A51
    ../User/Src/: main.c Task.c
